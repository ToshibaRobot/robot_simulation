Commit message: editing URDF file and adding launch command file

File: URDF/Toshiba_Robot_R01.urdf (robot description, URDF)
Before this commit: robot Toshiba_Robot_R01, 4 links, 3 joints
Joints:
- joint joint2: axis 1 0 0 -> 0 0 1
- joint joint3: axis 1 0 0 -> 0 0 1
